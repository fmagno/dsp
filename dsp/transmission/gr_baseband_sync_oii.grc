<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gr_baseband_sync_oii</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_correction</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>amplitude_calibration</value></param>
<param><key>label</key><value>amplitude calibration factor</value></param>
<param><key>short_id</key><value>y</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.7929649</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>comment</key><value>OUTPUT SIGNAL CH1</value></param>
<param><key>file</key><value>sig_out_ch1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>comment</key><value>OUTPUT SIGNAL CH2</value></param>
<param><key>file</key><value>sig_out_ch2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>comment</key><value>INPUT SIGNAL</value></param>
<param><key>file</key><value>sig_in</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>comment</key><value>EXEC DURATION</value></param>
<param><key>num_items</key><value>duration</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0_1</value></param>
<param><key>comment</key><value>EXEC DURATION</value></param>
<param><key>num_items</key><value>duration</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>AMPLITUDE CALIBRATION
FACTOR</value></param>
<param><key>const</key><value>amplitude_calibration</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>comment</key><value>LOOPBACK TEST</value></param>
<param><key>const</key><value>1./amplitude_calibration</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>duration</value></param>
<param><key>label</key><value>duration</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>red_pitaya_wide_sink</key>
<param><key>id</key><value>red_pitaya_wide_sink_0</value></param>
<param><key>addr</key><value>tx_ip</value></param>
<param><key>freq</key><value>center_freq</value></param>
<param><key>comment</key><value>TRANSMISSION</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>mask</key><value>3</value></param>
<param><key>ptt</key><value>True</value></param>
<param><key>port</key><value>1001</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>red_pitaya_wide_source</key>
<param><key>id</key><value>red_pitaya_wide_source_0</value></param>
<param><key>addr</key><value>rx_ip</value></param>
<param><key>freq</key><value>center_freq</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>mask</key><value>3</value></param>
<param><key>port</key><value>1001</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ip</value></param>
<param><key>label</key><value>rp reception ip</value></param>
<param><key>short_id</key><value>w</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>192.168.5.100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>sample rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sig_in</value></param>
<param><key>label</key><value>signal in</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./in.dat"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sig_out_ch1</value></param>
<param><key>label</key><value>signal output channel 1</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./r250000_ch1.dat"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sig_out_ch2</value></param>
<param><key>label</key><value>signal output channel 2</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./r250000_ch2.dat"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_ip</value></param>
<param><key>label</key><value>rp transmission ip</value></param>
<param><key>short_id</key><value>t</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>192.168.5.100</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_head_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0_1</source_block_id><sink_block_id>red_pitaya_wide_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>red_pitaya_wide_source_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
