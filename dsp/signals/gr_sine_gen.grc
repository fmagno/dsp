<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gr_sine_gen</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>absolute_path</value></param>
<param><key>value</key><value>dir_name + "/" + base_name</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>base_name</value></param>
<param><key>value</key><value>prefix + "r" + str(samp_rate).zfill(6) + "_f" + str(sig_freq).zfill(8) + "_d" + str(pre_padding) + "_g" + str(post_padding) + "_a" + str(sig_amp) + "_n" + str(ncycles).zfill(3) + "_u" + str(npulses) + "_p" + str(pwm_freq) + ".dat"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>duty_cycle</value></param>
<param><key>value</key><value>float(sig_on_samples)/sig_samples</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sig_off_samples</value></param>
<param><key>value</key><value>sig_samples-sig_on_samples</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sig_on_samples</value></param>
<param><key>value</key><value>int(samp_rate*ncycles/sig_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sig_samples</value></param>
<param><key>value</key><value>int(samp_rate/pwm_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total_time</value></param>
<param><key>value</key><value>float(sig_samples)/samp_rate</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>sig_amp</value></param>
<param><key>comment</key><value>SIGNAL</value></param>
<param><key>freq</key><value>sig_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>comment</key><value>OUTPUT SIGNAL</value></param>
<param><key>file</key><value>absolute_path</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>comment</key><value>PWM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>[0]*pre_padding + ([1]*sig_on_samples + [0]*sig_off_samples)*npulses + [0]*post_padding</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dir_name</value></param>
<param><key>label</key><value>dir name</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ncycles</value></param>
<param><key>label</key><value>number of cycles in a pulse</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>npulses</value></param>
<param><key>label</key><value>number of pulses</value></param>
<param><key>short_id</key><value>u</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>post_padding</value></param>
<param><key>label</key><value>post padding</value></param>
<param><key>short_id</key><value>b</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_padding</value></param>
<param><key>label</key><value>pre padding</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>prefix</value></param>
<param><key>short_id</key><value>j</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pwm_freq</value></param>
<param><key>label</key><value>frequency of the PWM signal</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>sample rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sig_amp</value></param>
<param><key>label</key><value>sgnal amplitude</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sig_freq</value></param>
<param><key>label</key><value>signal frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
