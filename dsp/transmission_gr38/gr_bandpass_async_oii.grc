options:
  parameters:
    generate_options: no_gui
    id: gr_bandpass_async_oii
    output_language: python
    run_options: run
  states: {}

blocks:
- name: amplitude_calibration1
  id: parameter
  parameters:
    label: amplitude calibration 1
    short_id: v
    type: complex
    value: '1'
  states: {}
- name: amplitude_calibration2
  id: parameter
  parameters:
    label: amplitude calibration 2
    short_id: b
    type: complex
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: OUTPUT SIGNAL 1
    file: sig_out1
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: OUTPUT SIGNAL 2
    file: sig_out2
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: INPUT SIGNAL
    file: sig_in
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: DURATION
    num_items: duration
    type: float
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    comment: DURATION
    num_items: duration
    type: float
  states: {}
- name: blocks_head_0_1
  id: blocks_head
  parameters:
    comment: DURATION
    num_items: duration
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: CALIBRATION 1
    const: amplitude_calibration1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: CALIBRATION 2
    const: amplitude_calibration2
    type: complex
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: center_freq
    short_id: c
    type: eng_float
    value: '0'
  states: {}
- name: ch_rx1
  id: parameter
  parameters:
    label: ch_rx1
    short_id: k
    type: intx
    value: '1001'
  states: {}
- name: ch_rx2
  id: parameter
  parameters:
    label: ch_rx2
    short_id: y
    type: intx
    value: '1002'
  states: {}
- name: ch_tx
  id: parameter
  parameters:
    label: ch_tx
    short_id: p
    type: intx
    value: '1001'
  states: {}
- name: duration
  id: parameter
  parameters:
    label: duration
    short_id: d
    type: intx
    value: '250000'
  states: {}
- name: red_pitaya_sink_xx_0
  id: red_pitaya_sink_xx
  parameters:
    addr: tx_ip
    corr: '0'
    freq: center_freq
    port: ch_tx
    ptt: 'True'
    rate: samp_rate
  states: {}
- name: red_pitaya_source_xx_0
  id: red_pitaya_source_xx
  parameters:
    addr: rx_ip1
    corr: '0'
    freq: center_freq
    port: ch_rx1
    rate: samp_rate
  states: {}
- name: red_pitaya_source_xx_0_0
  id: red_pitaya_source_xx
  parameters:
    addr: rx_ip2
    corr: '0'
    freq: center_freq
    port: ch_rx2
    rate: samp_rate
  states: {}
- name: rx_ip1
  id: parameter
  parameters:
    label: rx ip1
    short_id: e
    value: '"192.168.5.101"'
  states: {}
- name: rx_ip2
  id: parameter
  parameters:
    label: rx ip2
    short_id: t
    value: '"192.168.5.101"'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    short_id: r
    type: eng_float
    value: '250000'
  states: {}
- name: sig_in
  id: parameter
  parameters:
    label: signal in
    short_id: i
    value: '"./in.dat"'
  states: {}
- name: sig_out1
  id: parameter
  parameters:
    label: signal out 1
    short_id: o
    value: '"./out1.dat"'
  states: {}
- name: sig_out2
  id: parameter
  parameters:
    label: signal out 2
    short_id: l
    value: '"./out2.dat"'
  states: {}
- name: tx_ip
  id: parameter
  parameters:
    label: tx ip1
    short_id: w
    value: '"192.168.5.101"'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_real_0, '0', blocks_head_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_head_0_0, '0']
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_head_0_1, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_head_0_1, '0', red_pitaya_sink_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_complex_to_real_0_0, '0']
- [red_pitaya_source_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [red_pitaya_source_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
