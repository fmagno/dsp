options:
  parameters:
    generate_options: no_gui
    id: gr_baseband_sync_oii
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: amplitude_calibration
  id: parameter
  parameters:
    label: amplitude calibration factor
    short_id: y
    type: eng_float
    value: '3.7929649'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: OUTPUT SIGNAL CH1
    file: sig_out_ch1
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: OUTPUT SIGNAL CH2
    file: sig_out_ch2
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: INPUT SIGNAL
    file: sig_in
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    comment: EXEC DURATION
    num_items: duration
    type: complex
  states: {}
- name: blocks_head_0_0_1
  id: blocks_head
  parameters:
    comment: EXEC DURATION
    num_items: duration
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      AMPLITUDE CALIBRATION
      FACTOR
    const: amplitude_calibration
    type: complex
  states: {}
- name: duration
  id: parameter
  parameters:
    label: duration
    short_id: d
    type: intx
    value: '250000'
  states: {}
- name: red_pitaya_wide_sink_xx_0
  id: red_pitaya_wide_sink_xx
  parameters:
    addr: tx_ip
    corr: '0'
    freq: center_freq
    mask: '3'
    port: '1001'
    ptt: 'True'
    rate: samp_rate
  states: {}
- name: red_pitaya_wide_source_xx_0
  id: red_pitaya_wide_source_xx
  parameters:
    addr: rx_ip
    corr: '0'
    freq: center_freq
    mask: '3'
    port: '1001'
    rate: samp_rate
  states: {}
- name: rx_ip
  id: parameter
  parameters:
    label: rp reception ip
    short_id: w
    value: '''192.168.5.101'''
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    short_id: r
    type: eng_float
    value: '250000'
  states: {}
- name: sig_in
  id: parameter
  parameters:
    label: signal in
    short_id: i
    value: '"./in.dat"'
  states: {}
- name: sig_out_ch1
  id: parameter
  parameters:
    label: signal output channel 1
    short_id: o
    value: '"./r250000_ch1.dat"'
  states: {}
- name: sig_out_ch2
  id: parameter
  parameters:
    label: signal output channel 2
    short_id: l
    value: '"./r250000_ch2.dat"'
  states: {}
- name: tx_ip
  id: parameter
  parameters:
    label: rp transmission ip
    short_id: t
    value: '''192.168.5.100'''
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_file_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_head_0_0_1, '0']
- [blocks_head_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_head_0_0_1, '0', red_pitaya_wide_sink_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [red_pitaya_wide_source_xx_0, '0', blocks_head_0_0, '0']

metadata:
  file_format: 1
